# Keil uVision project CAN_TRANSMIT.uvprojx, settings and files
target CAN (6070000::V6.7::.\ARMCLANG)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.2.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CAN_TRANSMIT
  c flags: Optim=2 OneElfS=1 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CAN
    ./: can_.c can_.h
  group MLT
    ./MLT/: mlt_lcd.h mlt_font.h mlt_lcd.c
  group General
    ./: common.h machine.c machine.h rst.c rst.h myenum.h main.c
  group MAIN
    ./: main.h main.c
  group Button
    ./: button.c button.h
  group MENU
    ./: menu.c menu.h
  group HEXBIN
    ./: hexto.c hexto.h
software components: Device:Startup 2.1.0, Drivers:BKP 2.1.0, Drivers:CAN 2.0.3, Drivers:PORT 2.0.3, Drivers:POWER 2.1.0, Drivers:RST_CLK 2.0.3, Drivers:SSP 2.0.3, Drivers:TIMER 2.1.0
